FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://disable-usb-serial.cfg"