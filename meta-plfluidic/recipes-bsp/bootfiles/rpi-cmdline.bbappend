# Set HDMI-A-1 to always be on. Necessary to run weston w/o a monitor
CMDLINE_DEBUG = "video=HDMI-A-1:1920x1080M@60D"